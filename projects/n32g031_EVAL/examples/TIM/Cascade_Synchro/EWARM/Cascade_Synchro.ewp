# IAR project Cascade_Synchro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G031C8 Nations N32G031C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G032; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g031_std_periph_driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Cascade_Synchro.bin
  ILINK.IlinkOutputFile: Cascade_Synchro.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G031\N32G031x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g031.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g031_std_periph_driver/src/: misc.c n32g031_adc.c n32g031_comp.c n32g031_crc.c n32g031_dbg.c n32g031_dma.c n32g031_exti.c n32g031_flash.c n32g031_gpio.c n32g031_i2c.c n32g031_iwdg.c n32g031_lptim.c n32g031_pwr.c n32g031_rcc.c n32g031_tim.c n32g031_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g031_EWARM.S
  group USER
    ../src/: main.c n32g031_it.c
