# Keil uVision project Alarm.uvprojx, settings and files
target n32g031 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G031C8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Alarm +hex
  AfterMake: fromelf --bin --output=.\bin\Alarm.bin .\Objects\Alarm.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: n32g031, USE_STDPERIPH_DRIVER,
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g031_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g031.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g031.c
  group FWLB
    ../../../../../../firmware/n32g031_std_periph_driver/src/: misc.c n32g031_exti.c n32g031_gpio.c n32g031_rcc.c n32g031_rtc.c n32g031_usart.c n32g031_tim.c
  group USER
    ../src/: main.c n32g031_it.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
