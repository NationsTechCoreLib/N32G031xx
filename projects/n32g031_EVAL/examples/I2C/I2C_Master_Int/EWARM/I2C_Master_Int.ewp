# IAR project I2C_Master_Int.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G031C8 Nations N32G031C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G031; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g031_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Master_Int.bin
  ILINK.IlinkOutputFile: I2C_Master_Int.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g031.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g031_std_periph_driver/src/: misc.c n32g031_gpio.c n32g031_i2c.c n32g031_rcc.c n32g031_usart.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g031_EWARM.S
  group USER
    ../src/: main.c n32g031_it.c
