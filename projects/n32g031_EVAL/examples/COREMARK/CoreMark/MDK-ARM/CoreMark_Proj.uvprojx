# Keil uVision project CoreMark_Proj.uvprojx, settings and files
target N32G031 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32G031C8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CoreMark_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\CoreMark_Proj.bin .\Objects\CoreMark_Proj.axf
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G031, USE_STDPERIPH_DRIVER, SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  c include: ..\inc;..\coremark;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g031_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../startup/: startup_N32G031_CoreMark.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g031.c
  group FWLB
    ../../../../../../firmware/n32g031_std_periph_driver/src/: misc.c n32g031_crc.c n32g031_flash.c n32g031_gpio.c n32g031_rcc.c n32g031_usart.c
  group USER
    ../src/: main.c n32g031_it.c
  group COREMARK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../: readme.txt
