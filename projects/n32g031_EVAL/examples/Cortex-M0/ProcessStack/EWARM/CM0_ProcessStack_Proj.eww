<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CM0_ProcessStack_Proj.ewp</path>
  </project>
  <batchBuild/>
</workspace>


