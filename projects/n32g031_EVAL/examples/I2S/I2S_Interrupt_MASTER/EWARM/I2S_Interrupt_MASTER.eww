<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\I2S_Interrupt_MASTER.ewp</path>
  </project>
  <batchBuild/>
</workspace>


